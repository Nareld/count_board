# Keil uVision project count_board.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: count_board +hex
  c flags: Optimize=8 SizeSpeed=1
  group src
    ./: STARTUP.A51 main.c HC595.c delay.c HC595.h delay.h display.c display.h
